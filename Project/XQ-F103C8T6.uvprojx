# Keil uVision project XQ-F103C8T6.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XQ-F103C8T6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Hardware\LED;..\System\SYSTICK;..\Hardware\USART;..\Hardware\KEY;..\System\TIMER;..\Software\VOFA+;..\Hardware\IIC;..\Peripheral\OLED;..\Peripheral\AS5600;..\Arithmetic\FOC;..\Arithmetic\PWM;..\Arithmetic\PID;..\Arithmetic\FILTER;..\Peripheral\MPU6050;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\System\SYS;..\System\DELAY;..\Peripheral\SERVO;..\FreeRTOS\Malloc;..\System\FREERTOS_TIMER;..\Peripheral\BLUETOOTH;..\SimpleFOC;..\Software\MBOTLINUXUSART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c FreeRTOSConfig.h stm32f10x_conf.h FreeRTOSHandle.c
  group DOC
    ../Doc/: readme.txt
  group System
    ../System/SYSTICK/: systick.c
    ../System/TIMER/: timer.c
    ../System/DELAY/: delay.c
    ../System/SYS/: sys.c
    ../System/FREERTOS_TIMER/: freertos_timer.c
  group Hardware
    ../Hardware/LED/: led.c
    ../Hardware/USART/: usart.c
    ../Hardware/KEY/: key.c
    ../Hardware/IIC/: iic.c
  group Software
    ../Software/VOFA+/: vofa_JUSTfloat.c
    ../Software/MBOTLINUXUSART/: mbotLinuxusart.c
  group Peripheral
    ../Peripheral/AS5600/: as5600.c
    ../Peripheral/OLED/: oled_show.c
    ../Peripheral/MPU6050/: mpu6050.c
    ../Peripheral/SERVO/: servo.c
    ../Peripheral/BLUETOOTH/: bluetooth.c
  group Arithmetic
    ../Arithmetic/FOC/: foc.c
    ../Arithmetic/PWM/: pwm.c
    ../Arithmetic/PID/: pid.c
    ../Arithmetic/FILTER/: filter.c
  group Freertos
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/Malloc/: malloc.c
  group SimpleFOC
    ../SimpleFOC/: BLDCMotor.c foc_utils.c FOCMotor.c lowpass_filter.c MagneticSensor.c FOCpid.c
